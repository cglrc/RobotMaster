# Keil uVision project Dart.uvprojx, settings and files
target Dart (6220000::V6.22::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Dart +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=1
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;./APP_Task;./BSP_Can_Communication;./BSP_Uart_Communication;./Middle_Plugin;./Middle_SpecificCode;..\user
  asm include: ../Core/Inc;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s Dart.hex
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middle/Plugin
    ./Middle_Plugin/: InH.h InHpp.hpp Init.cpp Init.hpp MathUtils.cpp MathUtils.hpp Filter.cpp Filter.hpp PID.cpp PID.hpp StringUtil.cpp StringUtil.hpp
  group BSP/CanCommunication
    ./BSP_Can_Communication/: CanCallBack.cpp CanCallBack.hpp RmMotor.cpp RmMotor.hpp
  group BSP/UartCommunication
    ./BSP_Uart_Communication/: UartCallBack.cpp UartCallBack.hpp DT7.cpp DT7.hpp RMRefereeSystem.cpp RMRefereeSystem.hpp VofaCallBack.cpp VofaCallBack.hpp RMRefereeSystemCRC.cpp RMRefereeSystemCRC.hpp
  group APP/Task
    ./APP_Task/: Dart.cpp Dart.hpp MotorControl.cpp MotorControl.hpp UartSend.cpp UartSend.hpp SystemMonitor.cpp SystemMonitor.hpp Buzzer.cpp Buzzer.hpp MotorOfflineDetector.cpp MotorOfflineDetector.hpp ServoControl.cpp ServoControl.hpp VisionCommunication.cpp VisionCommunication.hpp auto.cpp auto.hpp HX711.cpp
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group user
    ../user/core/BSP/RemoteControl/: DT7.cpp DT7.hpp
    ../user/core/BSP/Common/StateWatch/: state_watch.cpp state_watch.hpp buzzer_manager.hpp buzzer_manager.cpp
    ../user/core/HAL/CAN/impl/: can_bus_impl.cpp can_device_impl.cpp
    ../user/core/HAL/CAN/interface/: can_bus.cpp can_device.cpp
software components: CMSIS:CORE 6.1.0
